#include "circular_layout.h"

static const uint8_t curve_lut[257] = {
    255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
    255,254,254,254,254,254,254,254,254,254,254,254,253,253,253,253,
    253,253,253,253,252,252,252,252,252,252,252,251,251,251,251,251,
    250,250,250,250,250,249,249,249,249,249,248,248,248,248,247,247,
    247,247,246,246,246,246,245,245,245,244,244,244,244,243,243,243,
    242,242,242,241,241,241,240,240,239,239,239,238,238,238,237,237,
    236,236,236,235,235,234,234,233,233,233,232,232,231,231,230,230,
    229,229,228,228,227,227,226,226,225,225,224,224,223,223,222,221,
    221,220,220,219,218,218,217,217,216,215,215,214,213,213,212,212,
    211,210,209,209,208,207,207,206,205,204,204,203,202,201,201,200,
    199,198,197,197,196,195,194,193,192,192,191,190,189,188,187,186,
    185,184,183,182,181,180,179,178,177,176,175,174,173,172,171,170,
    169,168,166,165,164,163,162,160,159,158,157,155,154,153,151,150,
    149,147,146,144,143,141,140,138,137,135,134,132,130,129,127,125,
    123,122,120,118,116,114,112,110,108,106,103,101, 99, 96, 94, 91,
     89, 86, 83, 80, 77, 74, 71, 67, 63, 59, 55, 50, 45, 39, 32, 23,
      0,
};

int32_t circular_safe_width(int32_t y_from_center, int32_t min_width)
{
    int32_t R = CIRCULAR_DISPLAY_RADIUS - CIRCULAR_SAFE_PAD;
    if(y_from_center < 0) y_from_center = -y_from_center;
    if(y_from_center >= R) return min_width;

    int32_t idx = y_from_center * 256 / R;
    int32_t w = CIRCULAR_CENTER_WIDTH * curve_lut[idx] / 255;

    if(w < min_width) w = min_width;
    if(w > CIRCULAR_CENTER_WIDTH) w = CIRCULAR_CENTER_WIDTH;
    return w;
}

int32_t circular_curve_factor(int32_t y_from_center)
{
    int32_t R = CIRCULAR_DISPLAY_RADIUS;
    if(y_from_center < 0) y_from_center = -y_from_center;
    if(y_from_center >= R) return 0;

    int32_t idx = y_from_center * 256 / R;
    return curve_lut[idx];
}
